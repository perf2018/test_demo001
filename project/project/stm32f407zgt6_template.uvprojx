# Keil uVision project stm32f407zgt6_template.uvprojx, settings and files
target 407zgt6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407zgt6_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\..\hardware;..\..\user;..\..\stdplibd\cmsis;..\..\stdplibd\stdlib\inc;..\..\hardware\led;..\..\hardware\usart\usart_debug;..\..\hardware\bitband;..\..\hardware\button;..\..\hardware\button_int;..\..\hardware\buzzer;..\..\hardware\dht11;..\..\hardware\ds18b20;..\..\hardware\iwdg;..\..\hardware\lcd;..\..\hardware\pm25;..\..\hardware\relay;..\..\hardware\rtc;..\..\hardware\systick;..\..\hardware\at24c02
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ../../stdplibd/cmsis/: startup_stm32f40_41xxx.s
  group cmsis
    ../../stdplibd/cmsis/: system_stm32f4xx.c
  group stplibd
    ../../stdplibd/stdlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_rtc.c stm32f4xx_iwdg.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_pwr.c
  group hardware
    ../../hardware/led/: led.c
    ../../hardware/usart/usart_debug/: bsp_usart.c
    ../../hardware/button/: button.c
    ../../hardware/button_int/: but_eint.c
    ../../hardware/buzzer/: buzzer.c
    ../../hardware/dht11/: dht.c
    ../../hardware/ds18b20/: ds_gpio.c ds18b20.c
    ../../hardware/iwdg/: iwdg.c
    ../../hardware/pm25/: adc_pm.c pm.c
    ../../hardware/relay/: relay.c
    ../../hardware/rtc/: rtc.c
    ../../hardware/systick/: systick.c
    ../../hardware/at24c02/: at24c02.c gpio_iic.c
    ../../hardware/lcd/: lcd.c
  group user
    ../../user/: main.c stm32f4xx_it.c
